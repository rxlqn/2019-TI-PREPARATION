# Keil uVision project project.uvproj, settings and files
target Flash (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: output +hex
  AfterMake: CopyHex_Flash.bat
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,ARM_MATH_CM4
  c misc: --diag_suppress=870
  c include: ..\..\Libraries\CMSIS\Include;..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\User\bsp_stm32f4xx\inc;..\..\User\bsp_stm32f4xx;..\..\User;..\..\User\MiddleWareDrv
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../../User/: main.c
  group BSP
    ../../User/bsp_stm32f4xx/src/: bsp_key.c bsp_led.c bsp_timer.c bsp_uart_fifo.c bsp_user_lib.c bsp_modbus.c
    ../../User/bsp_stm32f4xx/: stm32f4xx_it.c stm32f4xx_assert.c bsp.c
    ../../User/MiddleWareDrv/: DualTimerMasterSlave_MD.c
  group MDK-ARM
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40_41xxx.s
  group StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_rcc.c stm32f4xx_syscfg.c misc.c stm32f4xx_gpio.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_adc.c stm32f4xx_dma.c
  group CMSIS
    ../../User/bsp_stm32f4xx/: system_stm32f4xx.c
  group DSP_Lib
    ../../Libraries/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
  group Doc
    ../../Doc/: 03.开发环境说明.txt 04.STM32F407IGT6引脚定义(原始定义).txt 05.GPIO分配表(按GPIO次序排列).txt 06.GPIO分配表(按功能排列).txt
